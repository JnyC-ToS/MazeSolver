	AREA |.text|, CODE, READONLY
	ENTRY
	EXPORT __main

;	IMPORT MOTOR_INIT
;
;	IMPORT MOTOR_RIGHT_ON
;	IMPORT MOTOR_RIGHT_OFF
;	IMPORT MOTOR_RIGHT_FORWARD
;	IMPORT MOTOR_RIGHT_BACKWARD
;	IMPORT MOTOR_RIGHT_TOGGLE
;
;	IMPORT MOTOR_LEFT_ON
;	IMPORT MOTOR_LEFT_OFF
;	IMPORT MOTOR_LEFT_FORWARD
;	IMPORT MOTOR_LEFT_BACKWARD
;	IMPORT MOTOR_LEFT_TOGGLE

	IMPORT LED_INIT
	IMPORT LED_RIGHT_ON
	IMPORT LED_RIGHT_OFF
	IMPORT LED_LEFT_ON
	IMPORT LED_LEFT_OFF

;	IMPORT SWITCH_INIT
;	IMPORT SWITCH_1_PRESSED
;	IMPORT SWITCH_2_PRESSED

	IMPORT BUMPER_INIT
	IMPORT BUMPER_RIGHT_PRESSED
	IMPORT BUMPER_LEFT_PRESSED

__main
	; Initialisation
;	BL MOTOR_INIT
	BL LED_INIT
;	BL SWITCH_INIT
	BL BUMPER_INIT

__loop
	BL BUMPER_RIGHT_PRESSED
	BEQ __right_pressed
	BL LED_RIGHT_OFF
	B __right_end

__right_pressed
	BL LED_RIGHT_ON

__right_end

	BL BUMPER_LEFT_PRESSED
	BEQ __left_pressed
	BL LED_LEFT_OFF
	B __left_end

__left_pressed
	BL LED_LEFT_ON

__left_end

	B __loop

	NOP
	END
